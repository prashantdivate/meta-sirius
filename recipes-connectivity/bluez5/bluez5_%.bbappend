SRC_URI += "file://0001-bluez5-This-patch-activates-the-experimental-flag-wh.patch"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

