PACKAGECONFIG:append = " rdp fbdev launch"
